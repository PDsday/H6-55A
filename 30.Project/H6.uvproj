# Keil uVision project H6.uvproj, settings and files
target H6 (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: H6 +hex
  AfterMake: D:\software\Keil4\\ARM\ARMCC\bin\fromelf.exe  --bin -o  .\Bin\TestAPP.bin  ..\30.Project\ObjFile\H6.axf
  AfterMake: D:\software\Keil4\\StarsKeilMergeTool\StarsKeilMergeTool.exe -bin -stars -i .\Bin\TestAPP.bin  ..\..\..\H6_ARM_BOOT_RealTime\H6_ARM_BOOT_RealTime\BIN\CANopenBoot.bin -o ..\30.Project\Bin\Stars_ARM（CANopenBoot）.bin -s 0x08000000 -r 0x08010000 -y
  c flags: Optim=1 OneElfS=1 wLevel=1
  c define: STM32F4XX,USE_STDPERIPH_DRIVER,ARM_MATH_CM4, __FPU_PRESENT = 1,__CC_ARM,HSE_VALUE  = 8000000,TEST_FOR_STARS = 1
  c include: ..\20.MainTask;..\21.UserDataConfig;..\22.ConverState;..\23.CanopenConfig\CanopenData;..\23.CanopenConfig\CanopenDrive;..\23.CanopenConfig\CanopenEds;..\23.CanopenConfig\CanopenInit;..\23.CanopenConfig\CANopenUpdate;..\24.ModbusConfig;..\25.ChargerCom;..\26.DspCom;..\27.STM32F4xx\STM32F4xx_StartUp;..\27.STM32F4xx\STM32F4xx_StdPeriph_Driver\inc;..\27.STM32F4xx\STM32F4xx_StdPeriph_Driver\src;..\27.STM32F4xx\STM32F4xx_System;..\21.UserDataConfig\Gyro
  library: MicroLIB
  memory RVCT4: ROM 0x8010000 size 0x2ffff
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group 20.MainTask
    ../20.MainTask/: main.c
  group 21.UserDataConfig
    ../21.UserDataConfig/: adc_config.c BuildInfo.c CabinetTemp.c CL2351.c dac_config.c DefaultPara.c DSP_Programer.c ErrRecord.c Flash.c io.c MotoTemp.c ParaPreocess.c PLCFunction.c rtc.c rtcdata.c sdcard.c sdio_sdcard.c SSI.c SysInit.c TaskScheduler.c TimeBase.c state_machine.c AppFunc.c
    ../21.UserDataConfig/Gyro/: hardwareiic.C iim42652.c mpu6050.c
  group 22.ConverterState
    ../22.ConverState/: UserMainTask.c
  group 23_1.CanopenConfig
    ../23.CanopenConfig/CanopenData/: CANopenParaPreocess.c
    ../23.CanopenConfig/CanopenInit/: can_STM32.c store_STM32.c timer_STM32.c
    ../23.CanopenConfig/CanopenEds/: FD_ObjDict.c
    ../23.CanopenConfig/CanopenDrive/: dcf.c emcy.c lifegrd.c lss.c nmtMaster.c nmtSlave.c objacces.c pdo.c sdo.c states.c sync.c timer.c
  group 23_2.CANopenUpadte
    ../23.CanopenConfig/CANopenUpdate/: CANopenUpdate.c
  group 24.ModBusConfig
    ../24.ModbusConfig/: ExterUart.c
  group 25.ChargerCom
    ../25.ChargerCom/: InterUart2.c
  group 26.DspCom
    ../26.DspCom/: InterUart.c
  group 27.STM32F4xx
    ../27.STM32F4xx/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4x7_eth.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
    ../27.STM32F4xx/STM32F4xx_System/: system_stm32f4xx.c cpu_a.asm
    ../27.STM32F4xx/STM32F4xx_StartUp/: startup_stm32f4xx.s
